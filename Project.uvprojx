# Keil uVision project Project.uvprojx, settings and files
target STM32F051 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F051
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F051,USE_STM320518_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --C99
  c include: .\src;.\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\Libraries\STM32F0xx_CPAL_Driver\inc;.\Utilities\STM32_EVAL\Common;.\Utilities\STM32_EVAL\STM320518_EVAL;.\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group CMSIS
    ./Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f051.s
    ./src/: system_stm32f0xx.c
  group User
    ./src/: main.c stm32f0xx_it.c BluetoothDriver.c LcdDriver.c SerialConsole.c
  group StdPeriph_Driver
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
